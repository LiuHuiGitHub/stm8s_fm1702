# IAR project stm8s_fm1702_sw.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: DEBUG
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App; ..\ZLG_GUI; ..\FM1702
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s_fm1702_sw.hex
  ILINK.IlinkOutputFile: stm8s_fm1702_sw.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: NENCRYPT; NDEBUG
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App
  OBJCOPY.OOCOutputFile: BZ3101.hex
  ILINK.IlinkOutputFile: BZ3101.out
  group Driver
    ../Driver/: drive_lcd.c dvive_spi.c
  group FM1702
    ../FM1702/: drv_fm1702.c drv_fm1702_itf.c hwa_fm1702.c
  group Hwa
    ../Hwa/: hwa_eeprom.c hwa_eeprom_cfg.c hwa_key.c hwa_uart.c
  group System
    ../System/: sys_adc.c sys_clock.c sys_delay.c sys_eeprom.c sys_iniAppl.c sys_iniHw.c sys_iwdg.c sys_pwm.c sys_scheduler.c sys_sleep.c sys_task.c sys_uart.c sys_vector.c
  group zlgGui
    ../ZLG_GUI/: ConvertColor.c FONT24_32.C font5_7.c FONT8_8.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
