<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm8s_fm1702_sw.ewp</path>
  </project>
  <batchBuild/>
</workspace>


